## boards/shields/id_tb3/Kconfig.defconfig
```kconfig
if SHIELD_ID_TB3

config ZMK_KEYBOARD_NAME
    default "tb3"

endif # SHIELD_ID_TB3
```
